# The snapshot patches, for nativesdk-qemu-xilinx: t0-cosim-sdk's QEMU
require qemu-xilinx-snapshot.inc
