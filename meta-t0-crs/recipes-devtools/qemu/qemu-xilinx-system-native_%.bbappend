# The snapshot patches, for the native QEMU (a build tree's)
require qemu-xilinx-snapshot.inc
